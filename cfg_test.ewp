# IAR project cfg_test.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 256
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: DBG_BUG_ON_EN; SIMULATE_PW_FAIL
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.GStackSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  group (top)
    ./: aconv.c cfg.c cfg_cli.c cfg_test.c cli.c config.c crc16.c dbg_cli.c debug.c test_types.c uart.c ver_cli.c wdt.c
